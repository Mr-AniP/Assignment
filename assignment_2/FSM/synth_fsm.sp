* SPICE netlist generated by Yosys 0.37+27 (git sha1 ebf6128d9, clang 10.0.0-4ubuntu1 -fPIC -Os)

X0 in.0 1 INV_X1
X1 in.1 2 INV_X1
X2 state.1 3 INV_X1
X3 state.0 4 INV_X1
X4 state.2 5 INV_X1
X5 rst 6 INV_X1
X6 in.0 in.1 7 NOR2_X1
X7 state.1 4 state.2 8 NAND3_X1
X8 state.1 state.2 state.0 1 9 OAI211_X1
X9 7 9 10 OR2_X1
X10 in.0 in.1 11 NAND2_X1
X11 in.0 in.1 12 XNOR2_X1
X12 12 13 INV_X1
X13 state.1 4 14 15 AND3_X1
X14 state.1 state.0 16 OR2_X1
X15 14 state.0 state.1 17 OAI21_X1
X16 5 17 18 AND2_X1
X17 3 state.0 19 NAND2_X1
X18 in.0 2 20 NAND2_X1
X19 state.2 in.1 1 21 OAI21_X1
X20 state.1 4 5 22 NOR3_X1
X21 5 16 23 NOR2_X1
X22 20 22 23 11 24 AOI22_X1
X23 state.1 state.0 14 25 NAND3_X1
X24 11 25 26 NOR2_X1
X25 3 state.0 14 27 AND3_X1
X26 3 state.0 14 28 NAND3_X1
X27 5 11 17 29 NAND3_X1
X28 12 15 30 NAND2_X1
X29 26 27 in.1 13 18 31 AOI221_X1
X30 10 24 30 31 new_state.0 NAND4_X1
X31 25 2 in.0 32 AOI21_X1
X32 32 15 in.1 in.0 27 33 AOI221_X1
X33 in.0 in.1 18 34 NAND3_X1
X34 2 5 35 NOR2_X1
X35 3 state.2 4 in.1 36 OAI211_X1
X36 7 36 37 OR2_X1
X37 state.1 state.2 20 state.0 38 OAI211_X1
X38 33 34 37 38 new_state.1 NAND4_X1
X39 in.0 2 39 NOR2_X1
X40 18 39 40 NAND2_X1
X41 12 25 41 OR2_X1
X42 state.2 19 20 42 OAI21_X1
X43 2 state.1 4 14 43 NAND4_X1
X44 40 41 42 43 new_state.2 NAND4_X1
X45 1 state.1 state.0 state.2 44 NAND4_X1
X46 in.0 5 16 45 OR3_X1
X47 43 45 8 39 46 OAI211_X1
X48 in.1 28 44 47 AOI21_X1
X49 25 29 19 21 48 OAI211_X1
X50 46 47 48 outer.0 OR3_X1
X51 1 8 49 OR2_X1
X52 state.1 state.0 state.2 12 50 NAND4_X1
X53 27 32 35 3 51 AOI211_X1
X54 40 49 50 51 outer.1 NAND4_X1
X55 rst 52 INV_X1
X56 rst 53 INV_X1
X57 rst 54 INV_X1
X58 rst 55 INV_X1
X59 clk new_state.0 state.0 56 6 DFFR_X1
X60 clk new_state.1 state.1 57 52 DFFR_X1
X61 clk new_state.2 state.2 14 53 DFFR_X1
X62 clk outer.0 outery.0 58 54 DFFR_X1
X63 clk outer.1 outery.1 59 55 DFFR_X1
V0 outery.0 out.0 DC 0
V1 outery.1 out.1 DC 0

************************
* end of SPICE netlist *
************************
