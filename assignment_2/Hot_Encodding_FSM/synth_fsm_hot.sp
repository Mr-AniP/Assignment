* SPICE netlist generated by Yosys 0.37+27 (git sha1 ebf6128d9, clang 10.0.0-4ubuntu1 -fPIC -Os)

X0 state.0 1 INV_X1
X1 state.1 2 INV_X1
X2 state.2 3 INV_X1
X3 state.3 4 INV_X1
X4 state.4 5 INV_X1
X5 state.6 6 INV_X1
X6 state.7 7 INV_X1
X7 in.1 8 INV_X1
X8 rst 9 INV_X1
X9 state.6 state.7 10 NOR2_X1
X10 state.5 state.4 11 NOR2_X1
X11 state.5 state.6 state.7 12 NOR3_X1
X12 state.5 state.4 state.6 state.7 13 NOR4_X1
X13 state.0 state.1 14 NOR2_X1
X14 state.2 4 13 14 15 AND4_X1
X15 state.2 4 13 14 16 NAND4_X1
X16 state.2 state.3 17 NOR2_X1
X17 state.0 state.1 state.2 state.3 18 NOR4_X1
X18 state.5 5 10 18 19 AND4_X1
X19 19 20 INV_X1
X20 state.4 12 18 21 AND3_X1
X21 state.4 12 18 22 NAND3_X1
X22 19 21 23 NOR2_X1
X23 15 19 21 24 NOR3_X1
X24 state.0 2 13 17 25 AND4_X1
X25 state.0 2 13 17 26 NAND4_X1
X26 1 state.1 13 17 27 NAND4_X1
X27 26 27 28 AND2_X1
X28 state.6 7 11 18 29 NAND4_X1
X29 29 30 INV_X1
X30 6 state.7 11 18 31 AND4_X1
X31 3 state.3 13 14 32 AND4_X1
X32 31 32 33 NOR2_X1
X33 24 28 29 33 34 NAND4_X1
X34 8 in.0 35 NAND2_X1
X35 in.1 in.0 36 NOR2_X1
X36 in.1 in.0 37 OR2_X1
X37 34 35 20 37 28 new_state.0 OAI221_X1
X38 8 in.0 38 NOR2_X1
X39 38 39 INV_X1
X40 26 35 39 27 new_state.1 OAI22_X1
X41 in.1 in.0 40 NAND2_X1
X42 32 36 38 15 41 AOI22_X1
X43 41 35 27 26 40 new_state.2 OAI221_X1
X44 15 32 42 NOR2_X1
X45 40 42 27 new_state.3 AOI21_X1
X46 35 42 29 new_state.4 AOI21_X1
X47 25 38 43 NAND2_X1
X48 43 37 24 new_state.5 OAI21_X1
X49 31 36 44 AND2_X1
X50 in.1 in.0 45 XNOR2_X1
X51 44 45 30 46 AOI21_X1
X52 32 38 47 NAND2_X1
X53 46 47 22 40 new_state.6 OAI211_X1
X54 in.0 29 48 NOR2_X1
X55 37 48 31 49 OAI21_X1
X56 49 45 22 8 20 new_state.7 OAI221_X1
X57 in.1 19 25 40 50 AOI22_X1
X58 in.1 16 27 51 AOI21_X1
X59 50 38 29 in.0 23 52 OAI221_X1
X60 32 44 51 52 outer.0 OR4_X1
X61 in.0 30 32 35 45 31 53 AOI222_X1
X62 in.1 19 21 54 OAI21_X1
X63 27 43 53 54 outer.1 NAND4_X1
X64 rst 55 INV_X1
X65 rst 56 INV_X1
X66 rst 57 INV_X1
X67 rst 58 INV_X1
X68 rst 59 INV_X1
X69 rst 60 INV_X1
X70 rst 61 INV_X1
X71 rst 62 INV_X1
X72 rst 63 INV_X1
X73 clk new_state.0 state.0 64 9 DFFS_X1
X74 clk new_state.1 state.1 65 55 DFFR_X1
X75 clk new_state.2 state.2 66 56 DFFR_X1
X76 clk new_state.3 state.3 67 57 DFFR_X1
X77 clk new_state.4 state.4 68 58 DFFR_X1
X78 clk new_state.5 state.5 69 59 DFFR_X1
X79 clk new_state.6 state.6 70 60 DFFR_X1
X80 clk new_state.7 state.7 71 61 DFFR_X1
X81 clk outer.0 outery.0 72 62 DFFR_X1
X82 clk outer.1 outery.1 73 63 DFFR_X1
V0 outery.0 out.0 DC 0
V1 outery.1 out.1 DC 0

************************
* end of SPICE netlist *
************************
